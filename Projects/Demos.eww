<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.HA\EWARM\COM.MXCHIP.HA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.SPP\EWARM\COM.MXCHIP.SPP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.WECHAT.SPP\EWARM\COM.WECHAT.SPP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\platform_test\sample01\sample01.ewp</path>
  </project>
  <batchBuild/>
</workspace>


