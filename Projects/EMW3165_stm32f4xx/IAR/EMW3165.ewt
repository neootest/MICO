<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>HA</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>SPP</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>WECHAT</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Bootloader</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Applications</name>
    <group>
      <name>bootloader</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bootloader\BootloaderEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bootloader\Getline.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bootloader\menu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bootloader\Update_for_OTA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Bootloader\ymodem.c</name>
      </file>
    </group>
    <group>
      <name>HA</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\HaProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\UartRecv.c</name>
      </file>
    </group>
    <group>
      <name>SPP</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
      </file>
    </group>
    <group>
      <name>WECHAT</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MICOAppEntrance.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MICOBonjour.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MICOConfigDelegate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MicoVirtualDevice.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MVDCloudInterfaces.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Demos\COM.WECHAT.SPP\MVDDeviceInterfaces.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>EasyCloud</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\EasyCloud\EasyCloudService.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\EasyCloud\EasyCloudServiceDef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\EasyCloud\EasyCloudUtils.h</name>
      </file>
    </group>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <group>
      <name>EasyCloud</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\EasyCloud\MicoEasyCloudService_20150205_v0.3.0_debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Library\EasyCloud\MicoEasyCloudService_20150205_v0.3.0_release.a</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm4f_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm4f_spi.a</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>AirKiss</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\Airkiss\Airkiss.c</name>
      </file>
    </group>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\SoftAP\EasyLinkSoftAP.c</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOCli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOMfgtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>BoardConfig</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform_common_config.h</name>
      </file>
    </group>
    <group>
      <name>Common</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\crt0_IAR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\IAR\stdio_IAR.c</name>
        </file>
      </group>
      <group>
        <name>spi_flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\EMW3165.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\spi_flash.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>vendor</name>
      <group>
        <name>EMW1062_Driver</name>
        <group>
          <name>SDIO</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\SDIO\wlan_bus.c</name>
          </file>
        </group>
        <group>
          <name>SPI</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\SPI\wwd_bus.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\read_wifi_firmware.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\wlan_platform.c</name>
        </file>
      </group>
      <group>
        <name>STM32F4xx</name>
        <group>
          <name>STM32F4xx_StdPeriph_DRV</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\startup_stm32f411xe_bootloader_IAR.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\startup_stm32f411xe_IAR.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\system_stm32f4xx.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\gpio_irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverAdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverFlash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverGpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverI2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverPwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverRng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverRtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverSpi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverUart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverWdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\stm32f4xx_platform.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


