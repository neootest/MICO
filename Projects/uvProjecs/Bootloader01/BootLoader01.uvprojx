# Keil uVision project BootLoader01.uvprojx, settings and files
target Bootloader01 (ARM-ADS)
  device: STM32F205ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BootLoader01
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
