# Keil uVision project SPP.uvprojx, settings and files
target COM.MXCHIP.SPP (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPP
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c include: ..\..\..\include;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\CMSIS;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\..\..\Platform\Common\Cortex-M3\STM32F2xx;..\..\..\Platform\Common\Cortex-M3;..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc;..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\MICO;..\..\..\Platform\EMW3162;..\..\..\External;..\..\..\Library\support;..\..\..\Platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning 6654 --diag_warning 6238
  group Application
    ../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group MICO
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c
    ../../../MICO/EasyLink/: EasyLink.c
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../MICO/WPS/: WPS.c
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
  group support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External_jsonc
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform_vendor
    ../../../Platform/Common/Cortex-M3/: hardfault.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c usbh_conf.c
  group Platform_3162
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group platform_board
    ../../../Platform/EMW3162/: platform.c
    ../../../Platform/IDEs/Keil/: patch_keil.c
  group External_curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External_SHA
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group startup
    ../../../Platform/IDEs/Keil/: startup_stm32f2xx.s
    ../../../Platform/Common/Cortex-M3/: crt0_KEIL.c
