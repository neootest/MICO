<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EMW3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MICO_EVB_1</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Nucleo_411RE</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMW3165</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMW3161</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\HaProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\MICOConfigDelegate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.HA\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>GladmanAES</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aes_modes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aescrypt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aeskey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aestab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\gcm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\gf128mul.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverFlash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoDefaults.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm3_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm3_spi.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm4f_sdio.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm4f_spi.a</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\SoftAP\EasyLinkSoftAP.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOMfgtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>platform</name>
    <group>
      <name>Common</name>
      <group>
        <name>Cortex-M3</name>
        <group>
          <name>STM32F1xx</name>
        </group>
        <group>
          <name>STM32F2xx</name>
          <group>
            <name>EMW1062_Driver</name>
            <group>
              <name>SDIO</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\SDIO\wlan_bus.c</name>
              </file>
            </group>
            <group>
              <name>SPI</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\SPI\wwd_bus.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\read_wifi_firmware.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\wlan_platform.c</name>
            </file>
          </group>
          <group>
            <name>STM32F2xx_Drv</name>
            <group>
              <name>STM32F2xx_HAL_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
              </file>
            </group>
            <group>
              <name>STM32F2xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\startup_stm32f2xx_IAR.s</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\stm32f2xx.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\stm32f2xx_conf.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\system_stm32f2xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\gpio_irq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverAdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverFlash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverGpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverI2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverPwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverRng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverRtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverSpi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverUart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverWdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\stm32f2xx_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\crt0_IAR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\hardfault.c</name>
        </file>
      </group>
      <group>
        <name>Cortex-M4</name>
        <group>
          <name>STM32F4xx</name>
          <group>
            <name>EMW1062_Driver</name>
            <group>
              <name>SDIO</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\SDIO\wlan_bus.c</name>
              </file>
            </group>
            <group>
              <name>SPI</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\SPI\wwd_bus.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\read_wifi_firmware.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\EMW1062_Driver\wlan_platform.c</name>
            </file>
          </group>
          <group>
            <name>STM32F4xx_Drv</name>
            <group>
              <name>STM32F4xx_StdPeriph_Driver</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
              </file>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\startup_stm32f411xe_IAR.s</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\stm32f4xx.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\stm32f4xx_conf.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\system_stm32f4xx.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\gpio_irq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverAdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverFlash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverGpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverI2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverPwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverRng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverRtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverSpi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverUart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\MicoDriverWdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\STM32F4xx\stm32f4xx_platform.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\crt0_IAR.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M4\hardfault.c</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <group>
          <name>spi_flash</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\EMW3165.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\MICO_EVB_1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\Nucleo_411RE.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\Platform\Common\Drivers\spi_flash\spi_flash.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\IAR\stdio_IAR.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>EMW3161</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3161\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3161\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3161\platform_common_config.h</name>
      </file>
    </group>
    <group>
      <name>EMW3162</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3162\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3162\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3162\platform_common_config.h</name>
      </file>
    </group>
    <group>
      <name>EMW3165</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3165\platform_common_config.h</name>
      </file>
    </group>
    <group>
      <name>MICO_EVB_1</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\MICO_EVB_1\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\MICO_EVB_1\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\MICO_EVB_1\platform_common_config.h</name>
      </file>
    </group>
    <group>
      <name>Nucleo_411RE</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Nucleo_411RE\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Nucleo_411RE\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Nucleo_411RE\platform_common_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


