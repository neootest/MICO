<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\Sample01\AppEntrance.c</name>
    </file>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>json-c</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_cm3_sdio.a</name>
    </file>
  </group>
  <group>
    <name>Mico</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOEntranceT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\WPS\WPS.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Board</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\EMW3162\platform.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\IAR\stdio_IAR.c</name>
      </file>
    </group>
    <group>
      <name>vendor</name>
      <group>
        <name>stm32f2xx_hal</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_hcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_usb.c</name>
        </file>
      </group>
      <group>
        <name>stm32f2xxx_std_drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\system_stm32f2xx.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\crt0_IAR.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\gpio_irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\hardfault.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverAdc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverFlash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverGpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverI2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverPwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverRng.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverRtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverSpi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverUart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\MicoDriverWdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\read_wifi_firmware.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\stm32f2xx_platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\usbh_conf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\SDIO\wlan_bus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\EMW1062_Driver\wlan_platform.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


