<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>MiCOKit-3162</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-F205</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-3161</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>MiCOKit-G55</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\MicoDefaults.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>MiCOKit-G55</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Board\MiCOKit-G55\platform_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <group>
        <name>Core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\diskio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\ff_gen_drv.c</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\drivers\usbh_diskio.c</name>
        </file>
      </group>
      <group>
        <name>Options</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\syscall.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\External\FatFs\src\option\unicode.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>GladmanAES</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aes_modes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aescrypt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aeskey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\aestab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\GladmanAES\gf128mul.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
    <group>
      <name>SHAUtils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hkdf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\hmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha224-256.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\sha384-512.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\External\SHAUtils\usha.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>include</name>
    <group>
      <name>MicoDriver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverAdc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverGpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverI2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverMFiAuth.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverPwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRng.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverRtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverSpi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverUart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\include\MicoDrivers\MicoDriverWdg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\Debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICO.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAES.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoAlgorithm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoPlatform.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MICORTOS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSocket.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoSRPServer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\include\MicoWlan.h</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>AirKiss</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Airkiss\Airkiss.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Airkiss\Airkiss_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Airkiss\Airkiss_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\SoftAP\EasyLinkSoftAP.c</name>
      </file>
    </group>
    <group>
      <name>Library</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\MICOConfig.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\mxchipWNet_cm4f_spi.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\Library\RF driver\wlan_firmware.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WAC\MFi_WAC_CM3_Debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WAC\MFi_WAC_CM3_Release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOCli.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOMfgtest.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <group>
      <name>Cortex-M4</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\crt0_EWARM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\Cortex-M4\hardfault.c</name>
      </file>
    </group>
    <group>
      <name>Drivers</name>
      <group>
        <name>MFiAuth</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\MicoDriverMFiAuth\MicoDriverMFiAuth.a</name>
        </file>
      </group>
      <group>
        <name>SPI Flash</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\spi_flash\spi_flash_platform.c</name>
        </file>
      </group>
      <group>
        <name>STM32_USB_Host_Library</name>
        <group>
          <name>Class</name>
          <group>
            <name>MSC</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_bot.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Src\usbh_msc_scsi.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>Core</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_core.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ctlreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_ioreq.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Src\usbh_pipes.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\close.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\lseek.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\remove.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\EWARM\Retarget.c</name>
        <configuration>
          <name>MiCOKit-G55</name>
        </configuration>
      </file>
    </group>
    <group>
      <name>MCU</name>
      <group>
        <name>ATSAMG55</name>
        <group>
          <name>EWARM</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\EWARM\startup_ATSAMG55_EWARM.s</name>
          </file>
        </group>
        <group>
          <name>Peripherals</name>
          <group>
            <name>Libraries</name>
            <group>
              <name>common</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\utils\interrupt\interrupt_sam_nvic.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\sleepmgr\sam\sleepmgr.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\common\services\clock\samg\sysclk.c</name>
              </file>
            </group>
            <group>
              <name>sam</name>
              <group>
                <name>Drivers</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\efc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\flexcom.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\gpbr.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\pdc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\pio.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\pio_handler.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\pmc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\rtc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\sleep.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\smc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\spi.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\spi_master_vec.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\supc.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\twi.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\usart.c</name>
                </file>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\drivers\src\wdt.c</name>
                </file>
              </group>
              <group>
                <name>Services</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\sam\services\flash_efc\flash_efc.c</name>
                </file>
              </group>
            </group>
            <group>
              <name>samg55</name>
            </group>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\Libraries\system_samg55.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\paltform_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_mcu_powersave.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_pwm.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_uart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\peripherals\platform_watchdog.c</name>
          </file>
        </group>
        <group>
          <name>wlan_bus_driver</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\wlan_bus_driver\read_wifi_firmware.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\wlan_bus_driver\wlan_bus_spi.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\ATSAMG55\platform_init.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\mico_platform_common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Platform\MCU\wlan_platform_common.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Support\URLUtils.c</name>
    </file>
  </group>
</project>


