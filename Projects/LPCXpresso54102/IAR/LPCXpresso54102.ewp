# IAR project LPCXpresso54102.ewp, settings and files
configuration SPP_Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; IAR; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\BoardConfig\LPCXpresso54102; ..\..\..\Platform\Vendor\nxp\LPC54xx; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_common; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_540xx; ..\..\..\Platform\Vendor\nxp\LPC54xx\NXP_drivers\chip_540xx\config; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPCXpresso54102.bin
  ILINK.IlinkOutputFile: LPCXpresso54102.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\BoardConfig\LPCXpresso54102\LPC540xx_heap.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications/bootloader
    ../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Applications/HA
    ../../../Demos/COM.MXCHIP.HA/: HaProtocol.c LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c UartRecv.c
  group Applications/SPP
    ../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Applications/WECHAT
    ../../../Demos/COM.WECHAT.SPP/: MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoVirtualDevice.c MVDCloudInterfaces.c MVDDeviceInterfaces.c
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/EasyCloud
    ../../../include/EasyCloud/: EasyCloudService.h EasyCloudServiceDef.h EasyCloudUtils.h
  group include/MicoDriver
    ../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
  group Library/EasyCloud
    ../../../Library/EasyCloud/: MicoEasyCloudService_20150205_v0.3.0_debug.a MicoEasyCloudService_20150205_v0.3.0_release.a
  group MICO
    ../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AIRKISS
    ../../../MICO/Airkiss/: Airkiss.c
  group MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
  group MICO/EasyLinkSoftAP
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WPS
    ../../../MICO/WPS/: WPS.c
  group Platform/BoardConfig
    ../../../Platform/BoardConfig/LPCXpresso54102/: iar_startup_lpc540xx.s platform.c spi_flash_api.c
  group Platform/Common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: spi_flash.c
  group Platform/Common/IAR
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/vendor
    ../../../Platform/vendor/nxp/LPC54xx/: gpio_irq.c hardfault.c lpc_mico.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c platform_api.c rtc.c
  group Platform/vendor/EMW1062
    ../../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/vendor/EMW1062/SPI
    ../../../Platform/vendor/nxp/LPC54xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/vendor/LPC54xx
    ../../../Platform/vendor/nxp/LPC54xx/NXP_drivers/: board_nxp_lpcxpresso_54000.a chip_540xx_lib.a
  group support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
