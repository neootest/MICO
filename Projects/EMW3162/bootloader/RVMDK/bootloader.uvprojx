# Keil uVision project bootloader.uvprojx, settings and files
target EMW3162 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\Bootloader\EMW3162\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\EMW3162\Bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER SIZE_OPTIMIZE
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\CMSIS;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc;..\..\..\..\Bootloader;..\..\..\..\MICO;..\..\..\..\Platform\EMW3162;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Platform\EMW3162\bootloaderLinkerForKeil.sct
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
    ../../../../Platform/IDEs/Keil/: patch_keil.c
  group Support
    ../../../../Library/support/: StringUtils.c RingBufferUtils.c
  group Platform/STM32F2xx_StdPeriph_Driver
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c startup_stm32f2xx_bootloader_RVMDK.s
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/MicoDriver/MCU
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/: MicoDriverGpio.c MicoDriverUart.c stm32f2xx_platform.c MicoDriverSpi.c MicoDriverRng.c MicoDriverFlash.c MicoDriverRtc.c gpio_irq.c rtc.c
    ../../../../Platform/Common/Cortex-M3/: crt0_KEIL.c
  group Platform/Board
    ../../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
