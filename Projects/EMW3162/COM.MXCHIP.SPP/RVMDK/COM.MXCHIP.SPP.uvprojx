# Keil uVision project COM.MXCHIP.SPP.uvprojx, settings and files
target EMW3162 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COM.MXCHIP.SPP.axf
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\EMW3162\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\EMW3162\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\CMSIS;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Platform\EMW3162;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group MICO
    ../../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c MICOCli.c
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../../MICO/WPS/: WPS.c
  group Library
    ../../../../Library/: MICOConfig.c
    C:/Users/William/Documents/: mxchipWNet_cm3_sdio.a
  group Support
    ../../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform/STM32F2xx_StdPeriph_Driver
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: system_stm32f2xx.c startup_stm32f2xx_RVMDK.s
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/MicoDriver/EMW1062
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/MicoDriver/MCU
    ../../../../Platform/Common/Cortex-M3/: hardfault.c crt0_KEIL.c
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/: MicoDriverGpio.c MicoDriverI2c.c MicoDriverRtc.c MicoDriverUart.c stm32f2xx_platform.c usbh_conf.c rtc.c MicoDriverWdg.c MicoDriverSpi.c MicoDriverRng.c MicoDriverPwm.c MicoDriverFlash.c MicoDriverAdc.c gpio_irq.c
  group Board/EMW3162
    ../../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group Platform/KEIL
    ../../../../Platform/IDEs/Keil/: retarget.c thread_safe.c
    Y:/Develop/mxchipWNet Pro Demo@EMW316x/Platform/IDEs/Keil/: memory_debugger.lib
