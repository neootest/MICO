# IAR project Nucleo_411RE.ewp, settings and files
configuration HA (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.HA; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Nucleo_411RE.bin
  ILINK.IlinkOutputFile: Nucleo_411RE.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SPP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
configuration WECHAT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.WECHAT.SPP; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\include\EasyCloud; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
configuration bootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; BOOTLOADER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Bootloader; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_HAL_Driver\Inc
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\bootloaderLinkerForIAR.icf
  group Applications/Bootloader
    ../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Applications/HA
    ../../../Demos/COM.MXCHIP.HA/: HaProtocol.c LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c UartRecv.c
  group Applications/SPP
    ../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Applications/WECHAT
    ../../../Demos/COM.WECHAT.SPP/: MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoVirtualDevice.c MVDCloudInterfaces.c MVDDeviceInterfaces.c
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/EasyCloud
    ../../../include/EasyCloud/: EasyCloudService.h EasyCloudServiceDef.h EasyCloudUtils.h
  group include/MicoDriver
    ../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverFlash.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
  group Library/EasyCoud
    ../../../Library/EasyCloud/: MicoEasyCloudService_20150205_v0.3.0_debug.a MicoEasyCloudService_20150205_v0.3.0_release.a
  group MICO
    ../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AIRKISS
    ../../../MICO/Airkiss/: Airkiss.c
  group MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
    ../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WPS
    ../../../MICO/WPS/: WPS.c
  group Platform/BoardConfig
    ../../../Platform/Nucleo_411RE/: platform.c platform.h platform_common_config.h
  group Platform/common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: Nucleo_411RE.c spi_flash.c
  group Platform/common/IAR
    ../../../Platform/Common/Cortex-M4/: crt0_IAR.c
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/vendor
    ../../../Platform/Common/Cortex-M4/STM32F4xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f4xx_platform.c
    ../../../Platform/Common/Cortex-M4/: hardfault.c
  group Platform/vendor/EMW1062_Drv
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/vendor/EMW1062_Drv/SPI
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/vendor/stm32f411
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/: startup_stm32f411xe_bootloader_IAR.s startup_stm32f411xe_IAR.s system_stm32f4xx.c
  group Platform/vendor/stm32f411/StdPeriph_Drv
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
