# Keil uVision project COM.ALINK.HA.uvprojx, settings and files
target MX1101_EVB (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\MX1101_EVB\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\MX1101_EVB\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\MX1101_EVB;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals
  memory RVCT4: ROM 0xa000 size 0x76000
  memory RVCT9: RAM 0x20000000 size 0x1d800
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/COM.ALINK.HA/: device.c HaProtocol.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c thread_ota.c UartRecv.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group MICO
    ../../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c MICOCli.c
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../../MICO/WPS/: WPS.c
  group MICO/Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_8801.a
    ./../../../../MICO/Library/RF driver/: wlan_firmware.c
  group Support
    ../../../../Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/MX1101
    ../../../../Platform/MCU/MX1101/: platform_init.c
  group Platform/MCU/MX1101/RVMDK
    ../../../../Platform/MCU/MX1101/RVMDK/: startup_mx1101.s
  group Platform/MCU/MX1101/EMW1062
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/MCU/MX1101/wlan_bus_driver
    ../../../../Platform/MCU/MX1101/wlan_bus_driver/: read_wifi_firmware.c wlan_bus_sdio.c
  group Platform/MCU/MX1101/peripherals
    ../../../../Platform/MCU/MX1101/peripherals/: platform_mcu_powersave.c platform_gpio.c platform_flash.c platform_uart.c platform_adc.c platform_i2c.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_spi_slave.c platform_watchdog.c
  group Platform/MCU/MX1101/peripherals/Libraries
    ../../../../Platform/MCU/MX1101/peripherals/Libraries/: driver.lib
  group Board/EMW5062
    ../../../../Board/EMW5062/: platform.c platform.h platform_common_config.h
  group Board/MX1101_EVB
    ../../../../Board/MX1101_EVB/: platform.c platform.h platform_common_config.h
  group Board/MicoKit-3088
    ../../../../Board/MiCOKit-3088/: platform.c platform.h platform_config.h
  group Board/EMW5088
    ../../../../Board/EMW5088/: platform.c platform.h platform_config.h
  group External/rpc
    ../../../../External/rpc/: alink_mico.c alink_vendor_mico.c RpcLib-NO-DEBUG-0325.a
    D:/alink/: RpcLib-DEBUG-ALINK_DEBUG_0325.a
target EMW5062 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\EMW5062\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\EMW5062\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\EMW5062;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals
  memory RVCT4: ROM 0xa000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x1d800
  link misc: as above
target MicoKit-3088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\MiCOKit-3088\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\MiCOKit-3088\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\MicoKit-3088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals
  memory RVCT4: ROM 0xd000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238,L6436W,L6432W,L6433W --no_strict_wchar_size  --no_strict_enum_size
target EMW5088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.ALINK.HA.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.ALINK.HA\EMW5088\Obj_RVMDK\COM.ALINK.HA.axf --output ..\..\..\..\Build\COM.ALINK.HA\Output\EMW5088\COM.ALINK.HA.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: _PLATFORM_MICO_ DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\MICO;..\..\..\..\External;..\..\..\..\Support;..\..\..\..\Board\EMW5088;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Platform\MCU\MX1101\peripherals;..\..\..\..\Demos\COM.ALINK.HA;..\..\..\..\External\rpc;..\..\..\..\MICO\EasyLink
  memory RVCT4: ROM 0x5b000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x1f400
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238,L6436W,L6432W,L6433W,L6915E --no_strict_wchar_size  --no_strict_enum_size
