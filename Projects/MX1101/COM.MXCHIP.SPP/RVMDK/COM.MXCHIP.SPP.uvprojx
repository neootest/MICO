# Keil uVision project COM.MXCHIP.SPP.uvprojx, settings and files
target MX1101_EVB (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\AP80xx\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\AP80xx\COM.MXCHIP.SPP.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\MX1101\peripherals\Libraries\inc;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Board\MX1101_EVB;..\..\..\..\External;..\..\..\..\Library\support
  memory RVCT4: ROM 0xa000 size 0x76000
  memory RVCT9: RAM 0x20000000 size 0x1d800
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group MICO
    ../../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c MICOCli.c
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../../MICO/WPS/: WPS.c
  group Library
    ../../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_8801.a
  group Support
    ../../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_EWARM.c crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/IDEs/Keil/: memory_debugger.lib retarget.c thread_safe.c
  group Platform/MCU/MX1101/RVMDK
    ../../../../Platform/MCU/MX1101/RVMDK/: startup_mx1101.c
  group Platform/MCU/MX1101/peripherals/Libraries
    ../../../../Platform/MCU/MX1101/peripherals/Libraries/: driver.lib
  group Platform/MCU/MX1101/EMW1062
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
    ../../../../Platform/MCU/MX1101/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/MCU/MX1101/EMW1088
    ../../../../Platform/MCU/MX1101/EMW1088_Driver/: read_wifi_firmware.c wlan_bus.c wlan_platform.c
  group Platform/MCU/MX1101/peripherals
    ../../../../Platform/MCU/MX1101/peripherals/: MicoDriverAdc.c MicoDriverCommon.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c
  group Board/EMW5162
    ../../../../Platform/EMW5000/: platform.c platform.h platform_common_config.h
  group Board/MX1101_EVB
    ../../../../Board/MX1101_EVB/: platform.c platform.h platform_common_config.h
  group Board/EMW3088
    ../../../../Platform/EMW3088/: platform.c platform.h platform_common_config.h
target EMW5062 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\EMW5000\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\EMW5000\COM.MXCHIP.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Platform\EMW5000;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Platform\Common\Cortex-M3\CMSIS
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x1d800
  link misc: as above
target MicoKit3088 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Platform\EMW3088;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Platform\Common\Cortex-M3\CMSIS
  memory RVCT4: ROM 0x8000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x1d800
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238 --no_strict_wchar_size --no_strict_enum_size
