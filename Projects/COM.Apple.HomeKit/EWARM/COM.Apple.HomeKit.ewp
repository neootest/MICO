# IAR project COM.Apple.HomeKit.ewp, settings and files
configuration EMW3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.Apple.HomeKit; ..\..\..\MICO; ..\..\..\Platform\EMW3162; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.Apple.HomeKit.bin
  ILINK.IlinkOutputFile: COM.Apple.HomeKit.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICO_EVB_1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.Apple.HomeKit; ..\..\..\MICO; ..\..\..\Platform\MICO_EVB_1; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\MICO_EVB_1\micoLinkerForIAR.icf
  group Application
    ../../../Demos/COM.Apple.HomeKit/: HomeKitPairlist.c HomekitProfiles.c HomeKitSecurity_Debug.a HomeKitSecurity_Release.a HomeKitServer.c HomeKitUserInterface.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/HMAC_HKDF
    ../../../External/HMAC_HKDF/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Library
    ../../../Library/: MICOConfig.c MicoCrypto.a MicoSrpServer.a mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
  group MICO
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
  group MICO/WAC
    ../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../MICO/WPS/: WPS.c
  group Platform/Common/Cortex-M3
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
  group Platform/Common/Cortex-M3/STM32F2XX
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c
  group Platform/Common/Cortex-M3/STM32F2XX/EMW1062_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/Common/Cortex-M3/STM32F2XX/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/Common/Cortex-M3/STM32F2XX/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/Common/Cortex-M3/STM32F2XX/STM32F2xx_Drv
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: startup_stm32f2xx_IAR.s system_stm32f2xx.c
  group Platform/Common/Cortex-M3/STM32F2XX/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/Common/Drivers
    ../../../Platform/Common/Drivers/: MicoDriverMFiAuth.a
  group Platform/Common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: MICO_EVB_1.c spi_flash.c
  group Platform/Common/IAR
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/EMW3162
    ../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Platform/MICO_EVB_1
    ../../../Platform/MICO_EVB_1/: platform.c platform.h platform_common_config.h
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
