# Keil uVision project COM.MXCHIP.SPP.uvprojx, settings and files
target AP80xx (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.MXCHIP.SPP\AP80xx\Obj_RVMDK\COM.MXCHIP.SPP.axf --output ..\..\..\..\Build\COM.MXCHIP.SPP\Output\AP80xx\COM.MXCHIP.SPP.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Platform\AP80xx_EVB;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Platform\Common\Cortex-M3\CMSIS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\Platform\AP80xx_EVB\MicoLinkerForKeil.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group MICO
    ../../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c MICOCli.c
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../../MICO/WPS/: WPS.c
  group Library
    ../../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a
    ../../../../Platform/IDEs/Keil/: patch_keil_temp.c
  group Support
    ../../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Platform/AP80xx
    ../../../../Platform/Common/Cortex-M3/AP80xx/AP80xx_Drv/: startup_AP80xx_RVMDK.c driver.lib
  group Platform/MicoDriver/EMW1062
    ../../../../Platform/Common/Cortex-M3/AP80xx/EMW1062_Driver/: wlan_platform.c read_wifi_firmware.c
    ../../../../Platform/Common/Cortex-M3/AP80xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/MicoDriver/MCU
    ../../../../Platform/Common/Cortex-M3/: hardfault.c crt0_KEIL.c
    ../../../../Platform/Common/Cortex-M3/STM32F2xx/: MicoDriverI2c.c usbh_conf.c rtc.c MicoDriverSpi.c MicoDriverRng.c MicoDriverPwm.c MicoDriverAdc.c gpio_irq.c
    ../../../../Platform/Common/Cortex-M3/AP80xx/: MicoDriverWdg.c MicoDriverFlash.c MicoDriverCommon.c MicoDriverCommon_debug.c MicoDriverUart.c MicoDriverRtc.c MicoDriverGpio.c
  group Platform/Board/AP80xx_EVB
    ../../../../Platform/AP80xx_EVB/: platform.c platform.h platform_common_config.h
  group Platform/Board/EMW5000
    ../../../../Platform/EMW5000/: platform.c platform.h platform_common_config.h
target EMW5000 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: COM.MXCHIP.SPP.axf +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Demos\COM.MXCHIP.SPP;..\..\..\..\MICO;..\..\..\..\Platform\EMW5000;..\..\..\..\External;..\..\..\..\Library\support;..\..\..\..\Platform\include;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Platform\Common\Cortex-M3\CMSIS
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\..\Platform\EMW5000\MicoLinkerForKeil.sct
  link misc: as above
