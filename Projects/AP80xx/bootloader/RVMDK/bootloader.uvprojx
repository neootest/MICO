# Keil uVision project bootloader.uvprojx, settings and files
target EMW5162 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: bootloader +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\Bootloader\EMW5162\Obj_RVMDK\bootloader.axf --output ..\..\..\..\Build\Bootloader\Output\EMW5162\Bootloader.bin
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Library\support;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Bootloader;..\..\..\..\MICO;..\..\..\..\Platform\EMW5000;..\..\..\..\External;..\..\..\..\Platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c Update_for_OTA.c ymodem.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group Support
    ../../../../Library/support/: StringUtils.c RingBufferUtils.c
  group Platform/AP80xx
    ../../../../Platform/Common/Cortex-M3/AP80xx/AP80xx_Drv/: driver.lib startup_AP80xx_bootloader_RVMDK.c
  group Platform/MicoDriver/MCU
    ../../../../Platform/Common/Cortex-M3/AP80xx/: MicoDriverFlash.c MicoDriverGpio.c MicoDriverUart.c MicoDriverCommon.c
    ../../../../Platform/Common/Cortex-M3/: crt0_KEIL.c
  group Platform/KEIL
    ../../../../Platform/IDEs/Keil/: retarget.c thread_safe.c
    Y:/Develop/mxchipWNet Pro Demo@EMW316x/Platform/IDEs/Keil/: memory_debugger.lib
  group Board/EMW5162
    ../../../../Platform/EMW5000/: platform.c platform.h platform_common_config.h
  group Board/AP80xx_EVB
    ../../../../Platform/AP80xx_EVB/: platform.c platform.h platform_common_config.h
target AP80xx_EVB (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: as above
  output: bootloader +hex
  AfterMake: as above
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER BOOTLOADER
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\include;..\..\..\..\Library\support;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx__Drv;..\..\..\..\Platform\Common\Cortex-M3\AP80xx;..\..\..\..\Platform\Common\Cortex-M3;..\..\..\..\Platform\Common\Cortex-M3\AP80xx\AP80xx_Drv\inc;..\..\..\..\Bootloader;..\..\..\..\MICO;..\..\..\..\Platform\AP80xx_EVB;..\..\..\..\External;..\..\..\..\Platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
